# Keil uVision project HIT_QT_GLOVE_APP.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PEHB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HIT_QT_GLOVE_APP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ..\..\source;..\..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\..\drivers\cmsis\Include;..\..\drivers\hc32_ll_driver\inc;..\..\bsp;..\..\midwares\hc32\usb;..\..\midwares\hc32\usb\usb_device_lib\device_core;..\..\midwares\hc32\usb\usb_device_lib\device_class\single_cdc;..\..\midwares\3rd_party\FreeRTOS\Source\include;..\..\midwares\3rd_party\FreeRTOS\Source\CMSIS_RTOS;..\..\midwares\3rd_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\midwares\3rd_party\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f460.s
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../../source/: main.c app_led_task.c app_fingers_task.c app_usb_task.c app_wireless_task.c app_sample_task.c app_imu_task.c app_key_task.c app_usart_task.c app_tac_config.c
  group driver
    ../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group bsp
    ../../bsp/: ev_hc32f460_lqfp100_v2.c cdc_data_process.c usb_dev_desc.c usb_dev_user.c usb_bsp.c spi_fingers.c spi_imu.c iic_imu.c ai_wb2.c led.c adc_sample.c adc_bat.c usart_bsp.c
  group usb
    ../../midwares/hc32/usb/usb_device_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
    ../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc/: usb_dev_cdc_class.c
  group FreeRTOS
    ../../midwares/3rd_party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../midwares/3rd_party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../midwares/3rd_party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../midwares/3rd_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Readme
    ../: Readme.txt
